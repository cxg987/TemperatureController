# Keil uVision project modbus.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A08S2 STC12C5A16S2 Series
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x1FFF) CLOCK(45000000)
  output: swj +hex
  c flags: Optimize=4 SizeSpeed=1
  group Source Group 1
    ./: main.c uart.c PWM NEW.c AD.c
