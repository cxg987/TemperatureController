# Keil uVision project test1.1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F102R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test1
  c flags: Optim=1
  c define: STM32F10X_MD
  c include: ..\Source\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Source Group 1
    ./: STM32F10x.s
  group system
    ../SYSTEM/: delay.c sys.c
  group HARDWARE
    ../HARDWARE/: usart.c init.c
  group USER
    ./: main.c stm32f10x_flash.c
